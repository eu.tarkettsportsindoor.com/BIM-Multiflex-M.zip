Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2022-04-15T17:33:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.4.0.0 - Interface alternative d'export 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 15 17:33:25 2022 * Host: SWIFT * Database: C:\Users\M~1\AppData\Local\Temp\{35931F66-E256-4A9D-8E77-14E182CD1ED5}\ifc * Database version: 5507 * Database creation date: Fri Apr 15 17:33:24 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 15 17:33:24 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 15 17:33:24 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm
Autre - Adresse du projet: ## Rue Ville, Code postal; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: ## Rue Ville, Code postal; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey: Niveau:Pointe 8 mm, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: M_Marqueur de niveau - Cercle: M_Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Structure: no; Etage de bâtiment: yes; Nom: Niveau 1
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcBuildingElementProxy: Logo, TARKETT Sports - Logo:Logo:475792
In: Niveau 1
Type - Material: TARKETT - Logo - Bleu
Type - Autre - Catégorie: Modèles génériques; Nom de la famille: TARKETT Sports - Logo
Type - Contraintes - Elévation par défaut: 1219.2 mm
Type - Données d'identification - Nom du type: Logo
Type - Pset_BuildingElementProxyCommon - Reference: Logo
Type - Pset_QuantityTakeOff - Reference: Logo
Pset_BuildingElementProxyCommon - sets with these values: 2
Autre - Famille: TARKETT Sports - Logo: Logo; Famille et type: TARKETT Sports - Logo: Logo; ID du type: TARKETT Sports - Logo: Logo; Niveau de nomenclature: Niveau: Niveau 1; Type: TARKETT Sports - Logo: Logo
Contraintes - Niveau: Niveau: Niveau 1; Elévation: 0 mm; Hôte: Niveau : Niveau 1
Cotes - Surface: 2.16074 m2; Volume: 0.00213754 m3
Phase de construction - Phase de création: Nouvelle construction

# IfcBuildingElementProxy: Texte 3D:600mm Arial, Texte 3D:600mm Arial:355224
In: Niveau 1
Pset_BuildingElementProxyCommon - Reference: 600mm Arial; sets with these values: 2
Autre - Catégorie: Modèles génériques; Famille: Texte 3D: 600mm Arial; Famille et type: Texte 3D: 600mm Arial; ID du type: Texte 3D: 600mm Arial; Type: Texte 3D: 600mm Arial
Contraintes - Plan de construction: Niveau : Niveau 1
Cotes - Profondeur: 5 mm
Données d'identification - Sous-catégorie: Modèles génériques
Graphismes - Alignement horizontal: Centre; Texte: Multiflex
Phase de construction - Phase de création: Nouvelle construction
Autre(Type) - Catégorie: Modèles génériques; Nom de la famille: Texte 3D
Données d'identification(Type) - Nom du type: 600mm Arial
Texte(Type) - Gras: no; Italique: no; Police de texte: Arial; Taille du texte: 600 mm

# IfcBuildingElementProxy: Texte 3D:80mm Arial (2)
In: Niveau 1
Pset_BuildingElementProxyCommon - Reference: 80mm Arial; sets with these values: 2
Autre - Catégorie: Modèles génériques; Famille: Texte 3D: 80mm Arial; Famille et type: Texte 3D: 80mm Arial; ID du type: Texte 3D: 80mm Arial; Type: Texte 3D: 80mm Arial
Contraintes - Plan de construction: <non associé>
Cotes - Profondeur: 1 mm
Données d'identification - Sous-catégorie: Modèles génériques
Graphismes - Alignement horizontal: Centre
Phase de construction - Phase de création: Nouvelle construction
Autre(Type) - Catégorie: Modèles génériques; Nom de la famille: Texte 3D
Données d'identification(Type) - Nom du type: 80mm Arial
Texte(Type) - Gras: no; Italique: no; Police de texte: Arial; Taille du texte: 80 mm
Name (Texte 3D:80mm Arial:...) | Texte
472721 | Beech
472722 | Oak

# IfcCovering: Sol:TARKETT - Multiflex M - Beech, Sol:TARKETT - Multiflex M - Beech:372420
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - S'Match-it - Beech 38 mm
Type - Autre - Catégorie: Sols; Nom de la famille: Sol
Type - Construction - Epaisseur par défaut: 38 mm; Fonction: Intérieur
Type - Données - Resistencia a la tracción: 0; Abrasion: ≤ 0.8g; Absorción acústica: -; Absorción de impacto: A4 (≥55% <75%); Alargamiento a la rotura: -; Brillo especular: ≤ 45; Coeficiente de fricción: 80 a 110; Deformación vertical: A4; Dimensiones de las tablas: -; Emisiones COV tras 28 días: ≤ 100 μg/m³; Espesor capa de uso: 3.5 mm; Formato: 19.4 x 228.1 cm; Peso total: 16; Plastificante: -; Punzonamiento estático: ≤ 0.50 mm; Rango de temperatura: -; Rebote del Balón: ≥ 90%; Rendimiento acústico: -; Resistencia a cargas rodantes: Cumple
Type - Données d'identification - Code d'assemblage: C3020400; Commentaires du type: Beech; Coût: 0; Description: Pavimento deportivo de área elástica; Description de l'assemblage: Flooring; Fabricant: TARKETT; Modèle: Multiflex M; Nom du type: TARKETT - Multiflex M - Beech; URL: https://www.tarkettsportsindoor.com/
Type - Graphismes - Couleur vue détail faible: 0
Type - Propriétés analytiques - Coefficient d'absorbance: 0.1; Rugosité: 1
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Multiflex M - Beech; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Multiflex M - Beech
Type - PSet_Tarkett_ES - Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de área elástica; Design: Beech; Formato: 19.4 x 228.1 cm; Plastificante: -; Reacción al fuego: Cfl - s1; Absorción acústica: -; Punzonamiento estático: ≤ 0.50 mm; Peso total: 16; Espesor total: 38 mm; Emisiones COV tras 28 días: ≤ 100 μg/m³; URL: https://www.tarkettsportsindoor.com/; Espesor capa de uso: 3.5 mm; Abrasion: ≤ 0.8g; Absorción de impacto: A4 (≥55% <75%); Alargamiento a la rotura: -; Brillo especular: ≤ 45; Coeficiente de fricción: 80 a 110; Deformación vertical: A4; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 90%; Rendimiento acústico: -; Resistencia a cargas rodantes: Cumple
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 38 mm
Autre - Famille: Sol: TARKETT - Multiflex M - Beech; Famille et type: Sol: TARKETT - Multiflex M - Beech; ID du type: Sol: TARKETT - Multiflex M - Beech; Type: Sol: TARKETT - Multiflex M - Beech
Contraintes - Décalage par rapport au niveau: 0 mm; Lié au volume: no; Limite de pièce: yes; Niveau: Niveau: Niveau 1
Cotes - Elévation à la base: -38 mm; Elévation en haut: 0 mm; Epaisseur: 38 mm; Périmètre: 4000 mm; Surface: 1 m2; Volume: 0.038 m3
Phase de construction - Phase de création: Nouvelle construction
Structure - Activer le modèle analytique: no; Structure: no

# IfcCovering: Sol:TARKETT - Multiflex M - Oak, Sol:TARKETT - Multiflex M - Oak:372429
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - S'Match-it - Oak 38 mm
Type - Autre - Catégorie: Sols; Nom de la famille: Sol
Type - Construction - Fonction: Intérieur; Epaisseur par défaut: 38 mm
Type - Données - Resistencia a la tracción: 0; Abrasion: ≤ 0.8g; Absorción acústica: -; Absorción de impacto: A4 (≥55% <75%); Alargamiento a la rotura: -; Brillo especular: ≤ 45; Coeficiente de fricción: 80 a 110; Deformación vertical: A4; Dimensiones de las tablas: -; Emisiones COV tras 28 días: ≤ 100 μg/m³; Espesor capa de uso: 3.5 mm; Formato: 19.4 x 228.1 cm; Peso total: 16; Plastificante: -; Punzonamiento estático: ≤ 0.50 mm; Rango de temperatura: -; Rebote del Balón: ≥ 90%; Rendimiento acústico: -; Resistencia a cargas rodantes: Cumple
Type - Données d'identification - Code d'assemblage: C3020400; Commentaires du type: Oak; Coût: 0; Description: Pavimento deportivo de área elástica; Description de l'assemblage: Flooring; Fabricant: TARKETT; Modèle: Multiflex M; Nom du type: TARKETT - Multiflex M - Oak; URL: https://www.tarkettsportsindoor.com/
Type - Graphismes - Couleur vue détail faible: 0
Type - Propriétés analytiques - Rugosité: 1; Coefficient d'absorbance: 0.1
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Multiflex M - Oak; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Multiflex M - Oak
Type - PSet_Tarkett_ES - Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de área elástica; Design: Oak; Formato: 19.4 x 228.1 cm; Plastificante: -; Reacción al fuego: Cfl - s1; Absorción acústica: -; Punzonamiento estático: ≤ 0.50 mm; Peso total: 16; Espesor total: 38 mm; Emisiones COV tras 28 días: ≤ 100 μg/m³; URL: https://www.tarkettsportsindoor.com/; Espesor capa de uso: 3.5 mm; Abrasion: ≤ 0.8g; Absorción de impacto: A4 (≥55% <75%); Alargamiento a la rotura: -; Brillo especular: ≤ 45; Coeficiente de fricción: 80 a 110; Deformación vertical: A4; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 90%; Rendimiento acústico: -; Resistencia a cargas rodantes: Cumple
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 38 mm
Autre - Famille: Sol: TARKETT - Multiflex M - Oak; Famille et type: Sol: TARKETT - Multiflex M - Oak; ID du type: Sol: TARKETT - Multiflex M - Oak; Type: Sol: TARKETT - Multiflex M - Oak
Contraintes - Décalage par rapport au niveau: 0 mm; Lié au volume: no; Limite de pièce: yes; Niveau: Niveau: Niveau 1
Cotes - Elévation en haut: 0 mm; Elévation à la base: -38 mm; Epaisseur: 38 mm; Périmètre: 4000 mm; Surface: 1 m2; Volume: 0.038 m3
Phase de construction - Phase de création: Nouvelle construction
Structure - Activer le modèle analytique: no; Structure: no
